SRC_URI += "file://snickerdoodle_defconfig.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
